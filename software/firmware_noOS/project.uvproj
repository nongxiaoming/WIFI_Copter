# Keil uVision project project.uvproj, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: applications;.;Drivers;Libraries\STM32F2xx_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;.\Math
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Applications
    ./applications/: ANO_Config.cpp ANO_DT.cpp ANO_Filter.cpp ANO_FlyControl.cpp ANO_IMU.cpp ANO_Motor.cpp ANO_PID.cpp ANO_RC.cpp ANO_Scheduler.cpp AnoCopter.cpp
  group Drivers
    ./Drivers/: ANO_Drv_I2C_soft.cpp ANO_Drv_LED.cpp ANO_Drv_MPU6050.cpp ANO_Drv_Uart.cpp board.c stm32f2xx_it.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group Math
    ./Math/: ANO_Math.cpp ANO_Quaternion.cpp ANO_Vector3.cpp ANO_Matrix3.cpp
