# Keil uVision project project.uvproj, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: EMW3161  USE_STDPERIPH_DRIVER
  c include: applications;.;Drivers;Libraries\STM32F2xx_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;.\Math;.\Libraries\MXCHIP_Library;.\Libraries\CMSIS\CM3\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Applications
    ./applications/: params.c tcpserver.c config.cpp copter.cpp drv_mpu6050.cpp dt.cpp filter.cpp imu.cpp pid.cpp pidctrl.cpp rc.cpp scheduler.cpp
  group Drivers
    ./Drivers/: board.c stm32f2xx_it.c drv_i2c_soft.c drv_led.c drv_uart.c drv_wifi.c drv_motors.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
    ./Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_sdio.c stm32f2xx_rtc.c stm32f2xx_rng.c
  group Math
    ./Math/: ANO_Math.cpp ANO_Quaternion.cpp ANO_Vector3.cpp ANO_Matrix3.cpp
  group Mxchip
    ./Libraries/MXCHIP_Library/: mxchipWNet_3161.lib
